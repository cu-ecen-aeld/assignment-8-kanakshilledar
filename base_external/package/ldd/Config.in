## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes the ldd modules such as scull and scull variants as well as other miscellaneous modules.
```
